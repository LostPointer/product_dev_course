## projects/rc_vehicle/firmware/esp32/sdkconfig.defaults
```kconfig
# WebSocket support for esp_http_server (required for /ws handler)
CONFIG_HTTPD_WS_SUPPORT=y
```
